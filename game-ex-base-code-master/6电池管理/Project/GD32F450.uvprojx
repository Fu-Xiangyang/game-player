# Keil uVision project GD32F450.uvprojx, settings and files
target GD32F450 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F450ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F450 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Firmware\GD32F4xx_standard_peripheral\Include;..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32F4xx\Include;..\User;..\Hardware\led;..\Hardware\usart;..\Hardware\key;..\Hardware\timer;..\Hardware\pwm;..\Hardware\dma;..\Hardware\adc_key;..\Hardware\Lcd;..\Hardware\Gui;..\Hardware\IIC;..\Hardware\eeprom;..\Hardware\dac_audio;..\Hardware\adc_bat
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: systick.c main.c gd32f4xx_it.c sys.c
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group Hardware
    ../Hardware/led/: bsp_led.c
    ../Hardware/usart/: bsp_usart.c
    ../Hardware/key/: bsp_key.c
    ../Hardware/timer/: bsp_basic_timer.c
    ../Hardware/pwm/: bsp_pwm.c
    ../Hardware/dma/: bsp_dma.c
    ../Hardware/adc_key/: adc_Key.c
    ../Hardware/Lcd/: Spi4.c Lcd.c
    ../Hardware/Gui/: Gui.c
    ../Hardware/IIC/: i2c.c
    ../Hardware/eeprom/: eeprom.c
    ../Hardware/dac_audio/: dac_audio.c audio_source.c
    ../Hardware/adc_bat/: adc_bat.c
  group Firmware
    ../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_gpio.c gd32f4xx_rcu.c gd32f4xx_usart.c gd32f4xx_misc.c gd32f4xx_syscfg.c gd32f4xx_exti.c gd32f4xx_timer.c gd32f4xx_dma.c gd32f4xx_adc.c gd32f4xx_spi.c gd32f4xx_i2c.c gd32f4xx_dac.c
  group Doc
    ../Doc/: readme.txt
